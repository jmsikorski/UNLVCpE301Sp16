.ORG 0x100

.MACRO INITSTACK
	LDI		R16, HIGH(RAMEND)
	OUT		SPH, R16
	LDI		R17, LOW(RAMEND)
	OUT		SPL, R16
.ENDMACRO

DELAY:
	PUSH	R20
	LDI		R20, 0x0B
	STS		TCNT1H, R20
	LDI		R20, 0xDB
	STS		TCNT1L, R20
	LDI		R20, 0x00
	STS		TCCR1A, R20
	LDI		R20, 0x03
	STS		TCCR1B, R20
AGAIN:
	IN		R20, TIFR1
	SBRS	R20, TOV1
	RJMP	AGAIN
	LDI		R20, 0x00
	STS		TCCR1B, R20
	LDI		R20, 0x01
	OUT		TIFR1, R20
	POP		R20
	RET
